# Keil uVision project EV3UARTSensor-ultrasonic.uvproj, settings and files
target UARTSensor (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UARTSensor +hex
  AfterMake: C:\Users\14039\Desktop\MS51_Series_BSP_Keil_V1.00.002\MS51FB9AE_MS51XB9AE_MS51XB9BE_BSP_Keil\Library\Startup\EXE\hex2bin.exe
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\Library\Device\Include;..\..\Library\StdDriver\inc
  group Source
    ./: MessageSend.h MessageSend.c Sensor.h Sensor.c I2CDec.c I2CDev.h PWMLed.c PWMLed.h
    ../: main.c
  group Common
    ../../Library/StdDriver/src/: delay.c sys.c uart.c
  group Startup
    ../../Library/Startup/Keil/: STARTUP.A51
